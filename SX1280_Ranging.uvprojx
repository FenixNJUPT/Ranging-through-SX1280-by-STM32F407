# Keil uVision project SX1280_Ranging.uvprojx, settings and files
target SX1280_Ranging (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: SX1280_Ranging +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\SMTC_App;..\SMTC_Drivers\hw-hal\inc;..\SMTC_Drivers\sx1280-driver-c;..\SMTC_Drivers;..\SMTC_Drivers\DemoApp\Demo ranging;..\SMTC_Drivers\peripherals\rf_switch
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: gpio.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
    ../SMTC_App/: main_ranging.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_spi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group hw-hal
    ../SMTC_Drivers/hw-hal/src/: hw.c hw-gpio.c hw-spi.c hw-usart.c utilities.c
  group sx1280-driver-c
    ../SMTC_Drivers/sx1280-driver-c/: sx1280.c sx1280-hal.c
  group demo ranging
    ../SMTC_Drivers/DemoApp/Demo ranging/: demoRanging.c RangingDisplay.c
  group rf_switch
    ../SMTC_Drivers/peripherals/rf_switch/: rf_switch_cg2214m6.c
software components: CMSIS:CORE 4.3.0
